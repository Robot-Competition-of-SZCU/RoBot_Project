# Keil uVision project Robo.uvprojx, settings and files
target Robo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Robo +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --no-multibyte-chars
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;./User_Drivers/LED;./User_Drivers/KEY;./User_Drivers/Grayscale_ADC;./User_Drivers/Servo;./User_Drivers/Motor;./User_Drivers/Encoder;./User_Drivers/UART;./User_Drivers/OLED;./User_Drivers/Flash;./User_Application/Control;./User_Application/User_Task;./User_Application/Interrupt;./User_Application/PID;./User_Application/Set_And_Show;./User_Application/IMU;./User_Application/IO_Put;./User_Application/RUN_Process
  asm include: ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group User_Drivers
    ./User_Drivers/KEY/: KEY.c
    ./User_Drivers/LED/: LED.c
    ./User_Drivers/Motor/: Motor.c
    ./User_Drivers/Servo/: Servo.c
    ./User_Drivers/Grayscale_ADC/: Grayscale_ADC.c
    ./User_Drivers/Encoder/: Encoder.c
    ./User_Drivers/UART/: UART.c
    ./User_Drivers/OLED/: OLED.c OLED_Data.c
    ./User_Drivers/Flash/: Flash.c
  group User_Application
    ./User_Application/Control/: Control.c
    ./User_Application/User_Task/: User_Task.c
    ./User_Application/Interrupt/: Interrupt.c
    ./User_Application/PID/: PID.c
    ./User_Application/Set_And_Show/: Set_And_Show.c
    ./User_Application/IMU/: IMU.c
    ./User_Application/IO_Put/: IO_Put.c
    ./User_Application/RUN_Process/: RUN_Process.c
software components: CMSIS:CORE 6.2.0
